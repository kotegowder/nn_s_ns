# Keil uVision project nn_s.uvprojx, settings and files
target Target 1 (6070000::V6.7::.\ARMCLANG)
  device: Musca:Cortex-M33-0 ARM
  pack: ARM.Musca_A1_BSP.1.0.2
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10200000,0x00040000) IROM2(0x00200000,0x00040000) CPUTYPE("Cortex-M33") TZ CLOCK(12000000) ESEL ELITTLE
  output: nn_s +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __USE_FLASH
  c misc: -mcmse -D__ARM_FEATURE_CMSE=3 -D__DOMAIN_NS=0
  c include: ..\common
  memory RVCT4: ROM 0x10200000 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\sct\nn_s.sct
  link misc: --predefine="-D__USE_FLASH"
  group Source Group 1
    ./: s_main.c s_get_serial.c
    ../common/: serial.c get_serial.h serial.h region_defs.h region_limits.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Native Driver:Native UART 1.0.0
