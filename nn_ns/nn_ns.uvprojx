# Keil uVision project nn_ns.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: Musca:Cortex-M33-1 ARM
  pack: ARM.Musca_A1_BSP.1.0.2
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10200000,0x00040000) IROM2(0x00200000,0x00040000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: nn_ns
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x10200000 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
